inherit pypi setuptools3
require recipes-devtools/python/python-docker-pycreds.inc

SRC_URI[md5sum] = "322f570cea6b4661c6ac335683988e18"
SRC_URI[sha256sum] = "6ce3270bcaf404cc4c3e27e4b6c70d3521deae82fb508767870fdbf772d584d4"
