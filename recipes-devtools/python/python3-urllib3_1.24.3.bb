inherit pypi setuptools3
require recipes-devtools/python/python-urllib3.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ea114851ad9a8c311aac8728a681a067"

SRC_URI[md5sum] = "1efcddca675b80f3ac110439921fc66b"
SRC_URI[sha256sum] = "2393a695cd12afedd0dcb26fe5d50d0cf248e5a66f75dbd89a3d4eb333a61af4"
