inherit pypi setuptools3
require python-graphviz.inc
