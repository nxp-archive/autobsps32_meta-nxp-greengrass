inherit pypi setuptools3
DEPENDS += "${PYTHON_PN}-pip-native"
require recipes-devtools/python/python-docker.inc

SRC_URI[md5sum] = "a4e1f25103b46853cfcbc4c355cf74fa"
SRC_URI[sha256sum] = "a062a9f82dff025f79c2097c46f49f143f8898274db7e66041f78cafee66b962"
