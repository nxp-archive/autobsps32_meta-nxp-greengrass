inherit pypi setuptools
require recipes-devtools/python/python-docker-pycreds.inc

