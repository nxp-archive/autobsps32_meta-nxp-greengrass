inherit pypi setuptools
require python-graphviz.inc
