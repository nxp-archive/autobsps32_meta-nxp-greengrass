

SRC_URI = "https://github.com/LLAlex85/cacaovm/raw/master/${PV}.zip \
           file://system-boehm-gc.patch \
           file://cacao-1.6.1-do-not-rely-on-absolute-paths.patch \
"

